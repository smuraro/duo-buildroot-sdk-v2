## linux_5.10/drivers/misc/v4l2loopback/Kconfig
```kconfig
config V4L2LOOPBACK
        tristate "V4l2loopback"
        help
                Linux Kernel Module v4l2loopback.
```
